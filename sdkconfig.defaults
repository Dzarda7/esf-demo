## sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_FATFS_LFN_STACK=y
CONFIG_FATFS_MAX_LFN=32
CONFIG_SERIAL_FLASHER_PORT_USB_CDC_ACM=y
CONFIG_SERIAL_FLASHER_PORT_UART=n
```
